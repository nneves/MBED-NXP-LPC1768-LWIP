# Keil uVision project CMSIS_Example_LPC17xx.uvproj, settings and files
target MCB1700 (ARM-GNU)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  group src
    ../../../CoreSupport/: core_cm3.c
    ./: startup_LPC17xx.s system_LPC17xx.c main_LPC17xx.c
  group Documentation
    ./: Abstract.txt
target Simulator (ARM-GNU)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: CMSIS_Example
